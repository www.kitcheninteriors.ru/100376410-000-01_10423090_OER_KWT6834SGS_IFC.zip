Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-12-20T15:14:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Dec 20 15:14:59 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{6AC42240-C891-4173-957C-9BC4A8A485E6}\ifc * Database version: 5507 * Database creation date: Mon Dec 20 15:14:58 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Dec 20 15:14:58 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Dec 20 15:14:58 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 36683400_OER_10423090_KWT6834SGS, 10423090_OER_KWT6834SGS:36683400_OER_10423090_KWT6834SGS:213149
In: Level 1
Type - Material: Výchozí Nový materiál(1), z_Miele_Design_Glass Black, z_Miele_Design_Steel_Chrom, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel, z_Miele_Design_Alusilver, Default New Material, Poche, z_Miele_Design_Glass, z_Miele_Design_OBSW
Pset_BuildingElementProxyCommon - Reference: 36683400_OER_10423090_KWT6834SGS
Pset_ManufacturerTypeInformation - Manufacturer: Miele
